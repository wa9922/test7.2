options:
  parameters:
    author: AGC System
    description: AGC System Comparison (Low-Power vs High-Performance vs Adaptive)
    generate_options: qt_gui
    hier_block_src_path: .:.
    id: agc_comparison
    output_language: python
    title: AGC System Comparison
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '20000000'
  states: {}
- name: snr_db
  id: variable_qtgui_range
  parameters:
    label: SNR (dB)
    start: '0'
    step: '1'
    stop: '30'
    value: '10'
  states: {}
- name: traffic_type
  id: variable_qtgui_chooser
  parameters:
    label: Traffic Type
    label0: Low Power Signal
    label1: High Performance Signal
    num_opts: '2'
    option0: lowpowersignal
    option1: highperformancesignal
    type: string
    value: lowpowersignal
  states: {}
- name: packet_source
  id: epy_block
  parameters:
    _source_code: |
      import sys
      sys.path.insert(0, '/home/user/test7.2/gnu/python')
      from agc_packet_source import agc_packet_source
    packets_per_burst: '20'
    repeat: 'True'
    snr_db: snr_db
    traffic_type: traffic_type
  states: {}
- name: agc_low_power
  id: epy_block
  parameters:
    _source_code: |
      import sys
      sys.path.insert(0, '/home/user/test7.2/gnu/python')
      from agc_system_block import agc_system_block
    agc_mode: low_power
    enable_gain_feedback: 'False'
  states: {}
- name: agc_high_perf
  id: epy_block
  parameters:
    _source_code: |
      import sys
      sys.path.insert(0, '/home/user/test7.2/gnu/python')
      from agc_system_block import agc_system_block
    agc_mode: high_performance
    enable_gain_feedback: 'False'
  states: {}
- name: agc_adaptive
  id: epy_block
  parameters:
    _source_code: |
      import sys
      sys.path.insert(0, '/home/user/test7.2/gnu/python')
      from agc_system_block import agc_system_block
    agc_mode: adaptive
    enable_gain_feedback: 'True'
  states: {}
- name: ber_calc_lp
  id: epy_block
  parameters:
    _source_code: |
      import sys
      sys.path.insert(0, '/home/user/test7.2/gnu/python')
      from agc_ber_calc import agc_ber_calc
    adc_bits: '5'
    update_interval: '2560'
  states: {}
- name: ber_calc_hp
  id: epy_block
  parameters:
    _source_code: |
      import sys
      sys.path.insert(0, '/home/user/test7.2/gnu/python')
      from agc_ber_calc import agc_ber_calc
    adc_bits: '10'
    update_interval: '2560'
  states: {}
- name: ber_calc_adaptive
  id: epy_block
  parameters:
    _source_code: |
      import sys
      sys.path.insert(0, '/home/user/test7.2/gnu/python')
      from agc_ber_calc import agc_ber_calc
    adc_bits: '5'
    update_interval: '2560'
  states: {}
- name: power_meter_lp
  id: epy_block
  parameters:
    _source_code: |
      import sys
      sys.path.insert(0, '/home/user/test7.2/gnu/python')
      from agc_power_meter import agc_power_meter
    adc_bits: '5'
    sampling_rate: samp_rate
  states: {}
- name: power_meter_hp
  id: epy_block
  parameters:
    _source_code: |
      import sys
      sys.path.insert(0, '/home/user/test7.2/gnu/python')
      from agc_power_meter import agc_power_meter
    adc_bits: '10'
    sampling_rate: samp_rate
  states: {}
- name: power_meter_adaptive
  id: epy_block
  parameters:
    _source_code: |
      import sys
      sys.path.insert(0, '/home/user/test7.2/gnu/python')
      from agc_power_meter import agc_power_meter
    adc_bits: '5'
    sampling_rate: samp_rate
  states: {}
- name: qtgui_time_sink_lp
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 0,0,1,1
    label1: Low-Power
    size: '10240'
    srate: samp_rate
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_number_sink_ber
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 1,0,1,1
    label1: LP
    label2: HP
    label3: Adaptive
    max: '0.1'
    min: '0'
    name: BER
    nconnections: '3'
    type: float
  states: {}

connections:
- [packet_source, '0', agc_low_power, '0']
- [packet_source, '0', agc_high_perf, '0']
- [packet_source, '0', agc_adaptive, '0']
- [packet_source, packet_info, agc_low_power, traffic_info]
- [packet_source, packet_info, agc_high_perf, traffic_info]
- [packet_source, packet_info, agc_adaptive, traffic_info]
- [agc_low_power, '0', ber_calc_lp, '0']
- [agc_low_power, '0', power_meter_lp, '0']
- [agc_low_power, '0', qtgui_time_sink_lp, '0']
- [agc_high_perf, '0', ber_calc_hp, '0']
- [agc_high_perf, '0', power_meter_hp, '0']
- [agc_adaptive, '0', ber_calc_adaptive, '0']
- [agc_adaptive, '0', power_meter_adaptive, '0']
- [ber_calc_lp, '0', qtgui_number_sink_ber, '0']
- [ber_calc_hp, '0', qtgui_number_sink_ber, '1']
- [ber_calc_adaptive, '0', qtgui_number_sink_ber, '2']

metadata:
  file_format: 1
